IMAGE_FSTYPES:append = " \
	ext4.gz \
	"
